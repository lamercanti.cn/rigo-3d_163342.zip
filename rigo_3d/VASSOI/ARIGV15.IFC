Properties of the parts of a building model (IFC2X3)

# File
Description: IFC2X3
File name: .LEG015_VASSOIO D
Time: 2019-05-17T13:38:33
Author: dell1
Organization: Microsoft
Written by: SwIFC
Made in: SolidWorks 2013

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0 m

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0 m
